# Keil uVision project Lab-9-Transmitter.uvprojx, settings and files
target Lab9Transmitter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9Transmitter
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: AudioDriver.c AudioDriver.h DAC.c DAC.h InputDriver.c InputDriver.h Main.c Main.h startup.s TimerDriver.c TimerDriver.h tm4c123gh6pm.cmd Transmitter.c Transmitter.h UART0int.c
    ./inc/: ADCSWTrigger.c CortexM.c CortexM.h FIFO.h PLL.c PLL.h Timer2.c Timer2.h Timer3.c Timer3.h tm4c123gh6pm.h
target Audio (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: Lab9Transmitter
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.0.2
