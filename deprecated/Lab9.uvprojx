# Keil uVision project Lab9.uvprojx, settings and files
target Lab9 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c Timer2.c Timer3.c PortF.c Main.c Main.h AudioDriver.c AudioDriver.h LCDDriver.c LCDDriver.h SwitchDriver.c SwitchDriver.h TimerDriver.c TimerDriver.h ST7735.c ST7735.h DAC.c DAC.h Music.c Music.h PLL.h PortF.h Timer2.h Timer3.h InputDriver.c InputDriver.h Encoder.c Encoder.h Transmitter.c Transmitter.h Decoder.c Decoder.h
    ../inc/: LaunchPad.c LaunchPad.h ADCSWTrigger.c ADCSWTrigger.h Texas.h Texas.c
target Audio (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: Blynk
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.0.2
